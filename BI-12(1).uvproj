# Keil uVision project BI-12(1).uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F340 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(48000000)
  output: BI-12(1)
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\BI-12(1);.\wiznet\Ethernet;.\wiznet\Ethernet\W5500;C:\Keil_v5\C51\INC;C:\Keil_v5\C51\INC\SiLABS;C:\Keil_v5\C51\LIB;C:\Keil_v5\C51\BIN;D:\BI-12(1)
  group Source Group 1
    ./: main.c Device_Init.c my_fnc.c STARTUP.A51 my_wiznet.c
    ./wiznet/Ethernet/: wizchip_conf.c
    ./wiznet/Ethernet/W5500/: w5500.c
